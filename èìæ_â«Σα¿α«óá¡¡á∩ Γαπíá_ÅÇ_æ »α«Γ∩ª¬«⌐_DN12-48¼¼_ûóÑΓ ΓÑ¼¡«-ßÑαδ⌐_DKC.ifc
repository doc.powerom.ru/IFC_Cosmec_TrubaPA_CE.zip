Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:38:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:38:03 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{6FF88FDC-0787-4D5B-87B3-B38787F80951}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:38:03 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:38:03 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:38:03 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_581382
2 x OutPort_581398
InPort_581383
InPort_581384
2 x OutPort_581400
InPort_581385
InPort_581386
2 x OutPort_581402
InPort_581387
InPort_581388
2 x OutPort_581404
InPort_581389
InPort_581390
2 x OutPort_581406
InPort_581391
InPort_581392
2 x OutPort_581408
InPort_581393

# IfcFlowFitting: Неспецифицируемый_Гофрированная труба из ПА с протяжкой_темно-серый (6)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Гофрированная труба из ПА с протяжкой_темно-серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Гофрированная труба из ПА с протяжкой_темно-серый:...)
581398
581400
581402
581404
581406
581408

# IfcFlowSegment: Короб с соединительными деталями:КНС_Гофрированная труба_ПА_С протяжкой_DN12-48мм_Цвет темно-серый_DKC (12)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Гофрированная труба_ПА_С протяжкой_DN12-48мм_Цвет темно-серый_DKC
Name (Короб с соединительными деталями:КНС_Гофрированная труба_ПА_С протяжкой_DN12-48мм_Цвет темно-серый_DKC:...)
581382
581383
581384
581385
581386
581387
581388
581389
581390
581391
581392
581393
