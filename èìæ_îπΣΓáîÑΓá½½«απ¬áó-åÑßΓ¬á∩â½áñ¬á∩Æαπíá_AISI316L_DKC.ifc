Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:28:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:28:50 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{A8410A1B-F5A3-44A6-852C-BB7CB277934A}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:28:49 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:28:49 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:28:49 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: муфта DN 15 - DN20 жесткая труба, КНС_МуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:муфта DN 15 - DN20 жесткая труба:624062
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 15 - DN20 жесткая труба

# IfcFlowFitting: муфта DN 20 - DN25 жесткая труба, КНС_МуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:муфта DN 20 - DN25 жесткая труба:624066
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 20 - DN25 жесткая труба

# IfcFlowFitting: муфта DN 26 - DN32 жесткая труба, КНС_МуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:муфта DN 26 - DN32 жесткая труба:624070
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 26 - DN32 жесткая труба

# IfcFlowFitting: муфта DN 35 - DN40 жесткая труба, КНС_МуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:муфта DN 35 - DN40 жесткая труба:624074
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 35 - DN40 жесткая труба

# IfcFlowFitting: муфта DN 40 - DN50 жесткая труба, КНС_МуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:муфта DN 40 - DN50 жесткая труба:624078
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 40 - DN50 жесткая труба
