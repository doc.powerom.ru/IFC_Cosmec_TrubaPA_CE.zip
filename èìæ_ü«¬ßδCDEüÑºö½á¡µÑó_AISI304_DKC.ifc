Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:50:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:50:09 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{10A14D87-1F45-4B2E-BCAC-A7849DABE5CC}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:50:08 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:50:08 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:50:08 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 150 x 150 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:150 x 150 x 120 мм:709862
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 150 x 150 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE111201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE111201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 150 x 150 x 80 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:150 x 150 x 80 мм:709866
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 150 x 150 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE11801; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE11801/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 200 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:200 x 200 x 120 мм:709870
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 200 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE221201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE221201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 200 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:200 x 200 x 80 мм:709874
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 200 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE22801; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE22801/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 150 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:300 x 150 x 120 мм:709878
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 300 x 150 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE311201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE311201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:300 x 200 x 120 мм:709882
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 300 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE321201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE321201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:300 x 200 x 80 мм:709886
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 300 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE32801; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE32801/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:300 x 300 x 120 мм:709890
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 300 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE331201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE331201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:400 x 200 x 120 мм:709894
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 400 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE421201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE421201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:400 x 200 x 80 мм:709898
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 400 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE42801; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE42801/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:400 x 300 x 120 мм:709902
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 400 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE431201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE431201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 400 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:400 x 400 x 120 мм:709906
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 400 x 400 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE441201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE441201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:500 x 200 x 120 мм:709910
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 500 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE521201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE521201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:500 x 300 x 120 мм:709914
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 500 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE531201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE531201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:600 x 200 x 120 мм:709918
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 600 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE621201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE621201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:600 x 200 x 80 мм:709922
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 600 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE62801; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE62801/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:600 x 300 x 120 мм:709926
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 600 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE631201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE631201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 400 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:600 x 400 x 120 мм:709930
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 600 x 400 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE641201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE641201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:800 x 200 x 120 мм:709934
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 800 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE821201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE821201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:800 x 200 x 80 мм:709938
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 800 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE82801; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE82801/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 400 x 120 мм, КНС_БоксыCDEБезФланцев_AISI304_DKC:800 x 400 x 120 мм:709942
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_BuildingElementProxyCommon - Reference: 800 x 400 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE841201; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE841201/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcFlowFitting: 150x150 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 150x150 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:150x150 мм:...)
709864
709868

# IfcFlowFitting: 200x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 200x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:200x200 мм:...)
709872
709876

# IfcFlowFitting: 300x150 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x150 мм:709880
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x150 мм

# IfcFlowFitting: 300x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x200 мм:...)
709884
709888

# IfcFlowFitting: 300x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x300 мм:709892
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x300 мм

# IfcFlowFitting: 400x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x200 мм:...)
709896
709900

# IfcFlowFitting: 400x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x300 мм:709904
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x300 мм

# IfcFlowFitting: 400x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x400 мм:709908
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x400 мм

# IfcFlowFitting: 500x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:500x200 мм:709912
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 500x200 мм

# IfcFlowFitting: 500x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:500x300 мм:709916
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 500x300 мм

# IfcFlowFitting: 600x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x200 мм:...)
709920
709924

# IfcFlowFitting: 600x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x300 мм:709928
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x300 мм

# IfcFlowFitting: 600х400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600х400 мм:709932
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600х400 мм

# IfcFlowFitting: 800x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 800x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:800x200 мм:...)
709936
709940

# IfcFlowFitting: 800x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:800x400 мм:709944
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 800x400 мм
