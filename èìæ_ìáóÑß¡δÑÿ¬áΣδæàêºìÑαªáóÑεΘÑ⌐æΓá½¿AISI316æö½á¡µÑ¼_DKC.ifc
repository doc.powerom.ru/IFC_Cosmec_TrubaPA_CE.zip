Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:48:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:48:16 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{88B1A33C-DDAA-4000-B153-4F89C5150222}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:48:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:48:15 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:48:15 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 1000 х 600 х 250 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1000 х 600 х 250 мм:726604
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1000 х 600 х 250 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF10692; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF10692/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 х 600 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1000 х 600 х 300 мм:726606
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1000 х 600 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF10632; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF10632/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 х 600 х 400 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1000 х 600 х 400 мм:726608
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1000 х 600 х 400 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF10642; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF10642/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 х 800 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1000 х 800 х 300 мм:726610
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1000 х 800 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF10832; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF10832/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 х 800 х 400 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1000 х 800 х 400 мм:726612
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1000 х 800 х 400 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF10842; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF10842/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1200 х 600 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1200 х 600 х 300 мм:726614
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1200 х 600 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF12632; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF12632/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1200 х 800 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1200 х 800 х 300 мм:726616
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1200 х 800 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF12832; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF12832/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1400 х 600 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1400 х 600 х 300 мм:726620
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1400 х 600 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF14632; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF14632/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1400 х 800 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:1400 х 800 х 300 мм:726622
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1400 х 800 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF14832; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF14832/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 х 250 х 150 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:300 х 250 х 150 мм:726546
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 300 х 250 х 150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF03912; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF03912/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 х 300 х 150 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:300 х 300 х 150 мм:726548
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 300 х 300 х 150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF03312; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF03312/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 х 400 х 150 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:300 х 400 х 150 мм:726550
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 300 х 400 х 150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF03412; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF03412/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 х 300 х 150 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:400 х 300 х 150 мм:726552
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 400 х 300 х 150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF04312; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF04312/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 х 300 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:400 х 300 х 200 мм:726554
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 400 х 300 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF04322; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF04322/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 х 400 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:400 х 400 х 200 мм:726556
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 400 х 400 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF04422; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF04422/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 х 600 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:400 х 600 х 200 мм:726558
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 400 х 600 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF04622; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF04622/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 х 300 х 150 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:500 х 300 х 150 мм:726560
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 500 х 300 х 150 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF05312; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF05312/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 х 300 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:500 х 300 х 200 мм:726562
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 500 х 300 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF05322; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF05322/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 х 400 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:500 х 400 х 200 мм:726564
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 500 х 400 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF05422; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF05422/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 х 400 х 250 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:500 х 400 х 250 мм:726566
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 500 х 400 х 250 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF05492; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF05492/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 х 500 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:500 х 500 х 200 мм:726568
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 500 х 500 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF05522; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF05522/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 х 400 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:600 х 400 х 200 мм:726570
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 600 х 400 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF06422; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF06422/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 х 400 х 250 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:600 х 400 х 250 мм:726572
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 600 х 400 х 250 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF06492; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF06492/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 х 400 х 400 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:600 х 400 х 400 мм:726574
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 600 х 400 х 400 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF06442; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF06442/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 х 600 х 250 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:600 х 600 х 250 мм:726576
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 600 х 600 х 250 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF06692; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF06692/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 х 600 х 400 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:600 х 600 х 400 мм:726578
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 600 х 600 х 400 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF06642; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF06642/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 700 х 500 х 200 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:700 х 500 х 200 мм:726580
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 700 х 500 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF07522; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF07522/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 700 х 500 х 250 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:700 х 500 х 250 мм:726582
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 700 х 500 х 250 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF07592; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF07592/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 х 600 х 250 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:800 х 600 х 250 мм:726584
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 800 х 600 х 250 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF08692; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF08692/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 х 600 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:800 х 600 х 300 мм:726586
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 800 х 600 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF08632; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF08632/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 х 600 х 400 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:800 х 600 х 400 мм:726598
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 800 х 600 х 400 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF08642; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF08642/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 х 800 х 300 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:800 х 800 х 300 мм:726600
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 800 х 800 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF08832; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF08832/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 х 800 х 400 мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI316СФланцем_DKC:800 х 800 х 400 мм:726602
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 800 х 800 х 400 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEF08842; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEF08842/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус
