Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:12:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:12:15 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{FBADF59C-D280-4B45-A82D-A6CBA4E9DFC6}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:12:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:12:15 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:12:15 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: 122х82 мм, для коробок 128х103 мм, КНС_МонтажнаяПластина_DKC:122х82 мм, для коробок 128х103 мм:548326
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 122х82 мм, для коробок 128х103 мм

# IfcFlowFitting: 133х109 мм, для коробок 154х129 мм, КНС_МонтажнаяПластина_DKC:133х109 мм, для коробок 154х129 мм:548431
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 133х109 мм, для коробок 154х129 мм

# IfcFlowFitting: 165х124 мм, для коробок 178х155 мм, КНС_МонтажнаяПластина_DKC:165х124 мм, для коробок 178х155 мм:548440
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 165х124 мм, для коробок 178х155 мм

# IfcFlowFitting: 206х172 мм, для коробок 239х202 мм, КНС_МонтажнаяПластина_DKC:206х172 мм, для коробок 239х202 мм:548449
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 206х172 мм, для коробок 239х202 мм

# IfcFlowFitting: 254х210 мм, для коробок 294х244 мм, КНС_МонтажнаяПластина_DKC:254х210 мм, для коробок 294х244 мм:548458
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 254х210 мм, для коробок 294х244 мм

# IfcFlowFitting: 349х260 мм, для коробок 392х298 мм, КНС_МонтажнаяПластина_DKC:349х260 мм, для коробок 392х298 мм:548469
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 349х260 мм, для коробок 392х298 мм
