Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:02:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:02:27 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{F4050C96-70FB-404F-AE6F-C99239394528}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:02:26 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:02:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:02:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_577788
2 x OutPort_577825
InPort_577789
InPort_577791
2 x OutPort_577793
InPort_577792
InPort_577796
2 x OutPort_577798
InPort_577797
InPort_577801
2 x OutPort_577803
InPort_577802
InPort_577806
2 x OutPort_577808
InPort_577807
InPort_577811
2 x OutPort_577813
InPort_577812
InPort_577816
2 x OutPort_577818
InPort_577817
InPort_577821
2 x OutPort_577823
InPort_577822

# IfcFlowFitting: Неспецифицируемый_Металлорукав в гладкой EVA изоляции_серый (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в гладкой EVA изоляции_серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в гладкой EVA изоляции_серый:...)
577793
577798
577803
577808
577813
577818
577823
577825

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В гладкой EVA изоляции_DN10-50мм_Цвет серый_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В гладкой EVA изоляции_DN10-50мм_Цвет серый_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В гладкой EVA изоляции_DN10-50мм_Цвет серый_DKC:...)
577788
577789
577791
577792
577796
577797
577801
577802
577806
577807
577811
577812
577816
577817
577821
577822
