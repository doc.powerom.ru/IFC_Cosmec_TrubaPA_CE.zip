Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:12:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:12:44 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{679428F0-575F-4547-866C-FE38D81F2BA3}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:12:44 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:12:44 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:12:44 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: для горизонтальной установки в коробки 128х103 мм, КНС_ДинРейкаГоризонтальная_DKC:для горизонтальной установки в коробки 128х103 мм:553202
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: для горизонтальной установки в коробки 128х103 мм

# IfcFlowFitting: для горизонтальной установки в коробки 154х129 мм, КНС_ДинРейкаГоризонтальная_DKC:для горизонтальной установки в коробки 154х129 мм:553205
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: для горизонтальной установки в коробки 154х129 мм

# IfcFlowFitting: для горизонтальной установки в коробки 178х155 мм, КНС_ДинРейкаГоризонтальная_DKC:для горизонтальной установки в коробки 178х155 мм:553207
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: для горизонтальной установки в коробки 178х155 мм

# IfcFlowFitting: для горизонтальной установки в коробки 239х202 мм, КНС_ДинРейкаГоризонтальная_DKC:для горизонтальной установки в коробки 239х202 мм:553209
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: для горизонтальной установки в коробки 239х202 мм

# IfcFlowFitting: для горизонтальной установки в коробки 294х244 мм, КНС_ДинРейкаГоризонтальная_DKC:для горизонтальной установки в коробки 294х244 мм:553211
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: для горизонтальной установки в коробки 294х244 мм

# IfcFlowFitting: для горизонтальной установки в коробки 392х298 мм, КНС_ДинРейкаГоризонтальная_DKC:для горизонтальной установки в коробки 392х298 мм:553213
In: Этаж 01
Type - Material: DKC_Сталь_Горячеоцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: для горизонтальной установки в коробки 392х298 мм
