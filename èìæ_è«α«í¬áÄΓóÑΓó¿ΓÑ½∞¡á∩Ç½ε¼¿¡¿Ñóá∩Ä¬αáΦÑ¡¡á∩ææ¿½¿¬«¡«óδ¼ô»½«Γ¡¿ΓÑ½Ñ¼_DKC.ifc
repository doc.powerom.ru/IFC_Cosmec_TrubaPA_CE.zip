Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:15:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:15:40 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{C0418863-38F9-4179-BEB4-52C74B7655E3}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:15:39 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:15:40 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:15:40 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: 128х103х55мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашеннаяССиликоновымУплотнителем_DKC:128х103х55мм:630846
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 128х103х55мм

# IfcFlowFitting: 154х129х58мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашеннаяССиликоновымУплотнителем_DKC:154х129х58мм:630848
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 154х129х58мм

# IfcFlowFitting: 178х155х74мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашеннаяССиликоновымУплотнителем_DKC:178х155х74мм:630850
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 178х155х74мм

# IfcFlowFitting: 239х202х85мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашеннаяССиликоновымУплотнителем_DKC:239х202х85мм:630852
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 239х202х85мм

# IfcFlowFitting: 294х244х114мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашеннаяССиликоновымУплотнителем_DKC:294х244х114мм:630854
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 294х244х114мм

# IfcFlowFitting: 90х90х53мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашеннаяССиликоновымУплотнителем_DKC:90х90х53мм:631056
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 90х90х53мм
