Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:36:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:36:45 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{3E925371-6341-4ADB-8494-540D0B5EB413}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:36:45 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:36:45 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:36:45 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_581233
2 x OutPort_581249
InPort_581234
InPort_581235
2 x OutPort_581251
InPort_581236
InPort_581237
2 x OutPort_581253
InPort_581238
InPort_581239
2 x OutPort_581255
InPort_581240
InPort_581241
2 x OutPort_581257
InPort_581242
InPort_581243
2 x OutPort_581259
InPort_581244

# IfcFlowFitting: Неспецифицируемый_Гофрированная труба из ПА с протяжкой_черный (6)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Гофрированная труба из ПА с протяжкой_черный
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Гофрированная труба из ПА с протяжкой_черный:...)
581249
581251
581253
581255
581257
581259

# IfcFlowSegment: Короб с соединительными деталями:КНС_Гофрированная труба_ПА_С протяжкой_DN12-48мм_Цвет черный_DKC (12)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Гофрированная труба_ПА_С протяжкой_DN12-48мм_Цвет черный_DKC
Name (Короб с соединительными деталями:КНС_Гофрированная труба_ПА_С протяжкой_DN12-48мм_Цвет черный_DKC:...)
581233
581234
581235
581236
581237
581238
581239
581240
581241
581242
581243
581244
