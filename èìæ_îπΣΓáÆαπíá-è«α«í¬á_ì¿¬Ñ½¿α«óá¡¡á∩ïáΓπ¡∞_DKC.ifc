Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:24:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:24:01 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{F88F88C0-B0A6-4F29-BDD5-9FFC2BEF1858}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:24:01 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:24:01 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:24:01 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 16 - M16x1,5, КНС_МуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 16 - M16x1,5:611455
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 16 - M16x1,5

# IfcFlowFitting: DN 20 - M20x1,5, КНС_МуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 20 - M20x1,5:611457
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M20x1,5

# IfcFlowFitting: DN 25 - M25x1,5, КНС_МуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 25 - M25x1,5:611459
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 25 - M25x1,5

# IfcFlowFitting: DN 32 - M32x1,5, КНС_МуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 32 - M32x1,5:611461
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 32 - M32x1,5

# IfcFlowFitting: DN 40 - M40x1,5, КНС_МуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 40 - M40x1,5:611463
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M40x1,5

# IfcFlowFitting: DN 50 - M50x1,5, КНС_МуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 50 - M50x1,5:611465
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - M50x1,5

# IfcFlowFitting: DN 63 - M63x1,5, КНС_МуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 63 - M63x1,5:611467
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 63 - M63x1,5
