Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:37:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:37:43 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{5C07DCDC-2EBB-4F24-9FA7-B7252623AF66}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:37:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:37:43 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:37:43 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_580981
2 x OutPort_580997
InPort_580982
InPort_580983
2 x OutPort_580999
InPort_580984
InPort_580985
2 x OutPort_581001
InPort_580986
InPort_580987
2 x OutPort_581003
InPort_580988
InPort_580989
2 x OutPort_581005
InPort_580990
InPort_580991
2 x OutPort_581007
InPort_580992
InPort_580993
2 x OutPort_581009
InPort_580994
InPort_580995
2 x OutPort_581011
InPort_580996

# IfcFlowFitting: Неспецифицируемый_Гофрированная труба из ПА без протяжки_темно-серый (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Гофрированная труба из ПА без протяжки_темно-серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Гофрированная труба из ПА без протяжки_темно-серый:...)
580997
580999
581001
581003
581005
581007
581009
581011

# IfcFlowSegment: Короб с соединительными деталями:КНС_Гофрированная труба_ПА_Без протяжки_DN7-48мм_Цвет темно-серый_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Гофрированная труба_ПА_Без протяжки_DN7-48мм_Цвет темно-серый_DKC
Name (Короб с соединительными деталями:КНС_Гофрированная труба_ПА_Без протяжки_DN7-48мм_Цвет темно-серый_DKC:...)
580981
580982
580983
580984
580985
580986
580987
580988
580989
580990
580991
580992
580993
580994
580995
580996
