Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:51:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:51:02 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{1D86F759-B1D1-4DA0-BD89-69E78F20E072}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:51:01 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:51:02 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:51:02 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 300х200х120 мм, КНС_БоксыCDECФланцами_DKC:300х200х120 мм:702738
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300х200х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE32120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE32120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300х300х120 мм, КНС_БоксыCDECФланцами_DKC:300х300х120 мм:702746
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300х300х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE33120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE33120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400х200х120 мм, КНС_БоксыCDECФланцами_DKC:400х200х120 мм:702750
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400х200х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE42120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE42120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400х300х120 мм, КНС_БоксыCDECФланцами_DKC:400х300х120 мм:702758
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400х300х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE43120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE43120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400х400х120 мм, КНС_БоксыCDECФланцами_DKC:400х400х120 мм:702762
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400х400х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE44120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE44120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500х200х120 мм, КНС_БоксыCDECФланцами_DKC:500х200х120 мм:702766
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500х200х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE52120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE52120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500х300х120 мм, КНС_БоксыCDECФланцами_DKC:500х300х120 мм:702770
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500х300х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE53120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE53120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600х200х120 мм, КНС_БоксыCDECФланцами_DKC:600х200х120 мм:702774
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600х200х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE62120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE62120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600х300х120 мм, КНС_БоксыCDECФланцами_DKC:600х300х120 мм:702782
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600х300х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE63120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE63120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600х400х120 мм, КНС_БоксыCDECФланцами_DKC:600х400х120 мм:702786
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600х400х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE64120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE64120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800х200х120 мм, КНС_БоксыCDECФланцами_DKC:800х200х120 мм:702790
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800х200х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE82120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE82120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800х400х120 мм, КНС_БоксыCDECФланцами_DKC:800х400х120 мм:702798
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800х400х120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE84120F; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE84120F/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Комментарии к типоразмеру: Металлический корпус

# IfcFlowFitting: 300x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x200 мм:705738
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x200 мм

# IfcFlowFitting: 300x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x300 мм:705742
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x300 мм

# IfcFlowFitting: 400x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x200 мм:705744
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x200 мм

# IfcFlowFitting: 400x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x300 мм:705748
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x300 мм

# IfcFlowFitting: 400x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x400 мм:705750
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x400 мм

# IfcFlowFitting: 500x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:500x200 мм:705752
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 500x200 мм

# IfcFlowFitting: 500x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:500x300 мм:705754
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 500x300 мм

# IfcFlowFitting: 600x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x200 мм:705756
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x200 мм

# IfcFlowFitting: 600x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x300 мм:705760
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x300 мм

# IfcFlowFitting: 600x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x400 мм:705762
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x400 мм

# IfcFlowFitting: 800x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:800x200 мм:705764
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 800x200 мм

# IfcFlowFitting: 800x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:800x400 мм:705768
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 800x400 мм
