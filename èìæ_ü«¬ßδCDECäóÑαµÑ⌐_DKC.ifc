Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:51:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:51:27 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{0AE4D6B2-A694-4DF1-92D5-1C5D7444E68C}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:51:26 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:51:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:51:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 200 x 200 x 120 мм, КНС_БоксыCDECДверцей_DKC:200 x 200 x 120 мм:705976
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 200 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE22120C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE22120C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 200 x 200 x 80 мм, КНС_БоксыCDECДверцей_DKC:200 x 200 x 80 мм:705980
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 200 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE2280C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE2280C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 200 x 120 мм, КНС_БоксыCDECДверцей_DKC:300 x 200 x 120 мм:705988
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE32120C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE32120C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 200 x 80 мм, КНС_БоксыCDECДверцей_DKC:300 x 200 x 80 мм:705992
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE3280C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE3280C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 300 x 120 мм, КНС_БоксыCDECДверцей_DKC:300 x 300 x 120 мм:705996
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE33120C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE33120C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 200 x 120 мм, КНС_БоксыCDECДверцей_DKC:400 x 200 x 120 мм:706000
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE42120C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE42120C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 200 x 80 мм, КНС_БоксыCDECДверцей_DKC:400 x 200 x 80 мм:706004
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE4280C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE4280C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 300 x 120 мм, КНС_БоксыCDECДверцей_DKC:400 x 300 x 120 мм:706008
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE43120C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE43120C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 200 x 120 мм, КНС_БоксыCDECДверцей_DKC:500 x 200 x 120 мм:706016
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE52120C; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE52120C/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcFlowFitting: 200x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 200x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:200x200 мм:...)
708813
708815

# IfcFlowFitting: 300x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x200 мм:...)
708819
708821

# IfcFlowFitting: 300x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x300 мм:708823
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x300 мм

# IfcFlowFitting: 400x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x200 мм:...)
708825
708827

# IfcFlowFitting: 400x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x300 мм:708829
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x300 мм

# IfcFlowFitting: 500x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:500x200 мм:708833
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 500x200 мм
