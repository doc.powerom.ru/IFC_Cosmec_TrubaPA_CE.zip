Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:07:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:07:33 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{44692E71-55F6-4A57-A682-D6E2EE3457CA}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:07:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:07:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:07:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 10 - M12x1.5 д.5 - 9мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 10 - M12x1.5 д.5 - 9мм:590598
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10 - M12x1.5 д.5 - 9мм

# IfcFlowFitting: DN 10 - M16x1.5 д.5 - 9мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 10 - M16x1.5 д.5 - 9мм:590713
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10 - M16x1.5 д.5 - 9мм

# IfcFlowFitting: DN 10 - M20x1.5 д.8 - 12мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 10 - M20x1.5 д.8 - 12мм:590727
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10 - M20x1.5 д.8 - 12мм

# IfcFlowFitting: DN 12 - M12x1.5 д.5 - 9мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 12 - M12x1.5 д.5 - 9мм:590731
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - M12x1.5 д.5 - 9мм

# IfcFlowFitting: DN 12 - M16x1.5 д.5 - 9мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 12 - M16x1.5 д.5 - 9мм:590735
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - M16x1.5 д.5 - 9мм

# IfcFlowFitting: DN 12 - M20x1.5 д.8 - 12мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 12 - M20x1.5 д.8 - 12мм:590739
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - M20x1.5 д.8 - 12мм

# IfcFlowFitting: DN 15 - M12x1.5 д.5 - 9мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 15 - M12x1.5 д.5 - 9мм:590743
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - M12x1.5 д.5 - 9мм

# IfcFlowFitting: DN 15 - M16x1.5 д.5 - 9мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 15 - M16x1.5 д.5 - 9мм:590825
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - M16x1.5 д.5 - 9мм

# IfcFlowFitting: DN 15 - M20x1.5 д.8 - 12мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 15 - M20x1.5 д.8 - 12мм:590747
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - M20x1.5 д.8 - 12мм

# IfcFlowFitting: DN 15 - M25x1.5 д.11 - 16мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 15 - M25x1.5 д.11 - 16мм:590751
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - M25x1.5 д.11 - 16мм

# IfcFlowFitting: DN 20 - M20x1.5 д.11 - 16мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 20 - M20x1.5 д.11 - 16мм:590755
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M20x1.5 д.11 - 16мм

# IfcFlowFitting: DN 20 - M20x1.5 д.8 - 12мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 20 - M20x1.5 д.8 - 12мм:590759
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M20x1.5 д.8 - 12мм

# IfcFlowFitting: DN 20 - M25x1.5 д.11 - 16мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 20 - M25x1.5 д.11 - 16мм:590763
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M25x1.5 д.11 - 16мм

# IfcFlowFitting: DN 20 - M32x1.5 д.15 - 21мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 20 - M32x1.5 д.15 - 21мм:590767
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M32x1.5 д.15 - 21мм

# IfcFlowFitting: DN 26 - M20x1.5 д.11 - 16мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 26 - M20x1.5 д.11 - 16мм:590771
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - M20x1.5 д.11 - 16мм

# IfcFlowFitting: DN 26 - M25x1.5 д.11 - 16мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 26 - M25x1.5 д.11 - 16мм:590775
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - M25x1.5 д.11 - 16мм

# IfcFlowFitting: DN 26 - M25x1.5 д.15 - 21мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 26 - M25x1.5 д.15 - 21мм:590779
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - M25x1.5 д.15 - 21мм

# IfcFlowFitting: DN 26 - M32x1.5 д.15 - 21мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 26 - M32x1.5 д.15 - 21мм:590783
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - M32x1.5 д.15 - 21мм

# IfcFlowFitting: DN 26 - M40x1.5 д.20 - 27мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 26 - M40x1.5 д.20 - 27мм:590787
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - M40x1.5 д.20 - 27мм

# IfcFlowFitting: DN 35 - M32x1.5 д.15 - 21мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 35 - M32x1.5 д.15 - 21мм:590791
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 35 - M32x1.5 д.15 - 21мм

# IfcFlowFitting: DN 35 - M40x1.5 д.20 - 27мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 35 - M40x1.5 д.20 - 27мм:590795
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 35 - M40x1.5 д.20 - 27мм

# IfcFlowFitting: DN 40 - M40x1.5 д.20 - 27мм, КНС_МуфтаМеталлорукав-КоробкаСУплотнениемКабеля_DKC:DN 40 - M40x1.5 д.20 - 27мм:590799
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M40x1.5 д.20 - 27мм
