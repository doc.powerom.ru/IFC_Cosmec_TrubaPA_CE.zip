Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:19:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:19:31 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{C3B8249F-B8FC-4DBF-A9B8-F09B3D8309F0}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:19:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:19:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:19:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: Муфта труба-труба (12)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Муфта труба-труба
Name (КНС_МуфтаТруба-Труба_AISI316L_DKC:Муфта труба-труба:...)
843846
843848
843852
843854
843859
843861
843866
843868
843873
843875
843880
843882

# IfcFlowFitting: Поворот на 90° (6)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Поворот на 90°
Name (КНС_ПоворотНа90ГрадусовИзНержавеющейСталиAISI304_DKC:Поворот на 90°:...)
606699
606709
606711
606713
606715
606717
