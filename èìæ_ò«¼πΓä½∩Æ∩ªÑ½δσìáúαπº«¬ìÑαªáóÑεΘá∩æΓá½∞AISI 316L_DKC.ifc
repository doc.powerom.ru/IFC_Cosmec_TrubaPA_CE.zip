Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:32:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:32:14 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{A4EB689E-4459-4468-AB7C-B2BEB018E4D8}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:32:13 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:32:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:32:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: D20-24_Cталь AISI316L, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 316L_DKC:D20-24_Cталь AISI316L:655324
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D20-24_Cталь AISI316L

# IfcFlowFitting: D25-29_Cталь AISI316L, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 316L_DKC:D25-29_Cталь AISI316L:655327
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D25-29_Cталь AISI316L

# IfcFlowFitting: D32-36_Сталь AISI316L, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 316L_DKC:D32-36_Сталь AISI316L:655329
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D32-36_Сталь AISI316L

# IfcFlowFitting: D40-45_Cталь AISI316L, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 316L_DKC:D40-45_Cталь AISI316L:655331
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D40-45_Cталь AISI316L

# IfcFlowFitting: D47-51_Cталь AISI316L, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 316L_DKC:D47-51_Cталь AISI316L:655333
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D47-51_Cталь AISI316L
