Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:38:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:38:24 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{CC18FFCC-4848-434D-890D-E5369A7D0022}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:38:24 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:38:24 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:38:24 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (36)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_581876
2 x OutPort_583561
InPort_581877
InPort_581878
2 x OutPort_583553
InPort_581879
InPort_581880
2 x OutPort_583545
InPort_581881
InPort_581882
2 x OutPort_583537
InPort_581883
InPort_581884
2 x OutPort_583529
InPort_581885
InPort_581886
2 x OutPort_583521
InPort_581887
InPort_581888
2 x OutPort_583513
InPort_581889
InPort_581890
2 x OutPort_583505
InPort_581891
InPort_583487
2 x OutPort_583497
InPort_583488

# IfcFlowFitting: Неспецифицируемый_Гофрированная труба из самозатухающего ПА без протяжки_темно-серый (9)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Гофрированная труба из самозатухающего ПА без протяжки_темно-серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Гофрированная труба из самозатухающего ПА без протяжки_темно-серый:...)
583497
583505
583513
583521
583529
583537
583545
583553
583561

# IfcFlowSegment: Короб с соединительными деталями:КНС_Гофрированная труба_Самозатухающий ПА_Без протяжки_DN10-50мм_Цвет темно-серый_DKC (18)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Гофрированная труба_Самозатухающий ПА_Без протяжки_DN10-50мм_Цвет темно-серый_DKC
Name (Короб с соединительными деталями:КНС_Гофрированная труба_Самозатухающий ПА_Без протяжки_DN10-50мм_Цвет темно-серый_DKC:...)
581876
581877
581878
581879
581880
581881
581882
581883
581884
581885
581886
581887
581888
581889
581890
581891
583487
583488
