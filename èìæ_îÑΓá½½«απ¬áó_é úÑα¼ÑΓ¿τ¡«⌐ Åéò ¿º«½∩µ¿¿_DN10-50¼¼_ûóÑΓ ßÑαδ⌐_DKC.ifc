Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T12:54:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 12:54:37 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{4FE66245-FAFC-4028-A4BB-2BE6C7152418}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 12:54:36 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 12:54:37 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 12:54:37 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_574101
2 x OutPort_574138
InPort_574102
InPort_574104
2 x OutPort_574106
InPort_574105
InPort_574109
2 x OutPort_574111
InPort_574110
InPort_574114
2 x OutPort_574116
InPort_574115
InPort_574119
2 x OutPort_574121
InPort_574120
InPort_574124
2 x OutPort_574126
InPort_574125
InPort_574129
2 x OutPort_574131
InPort_574130
InPort_574134
2 x OutPort_574136
InPort_574135

# IfcFlowFitting: Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции_серый (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции_серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции_серый:...)
574106
574111
574116
574121
574126
574131
574136
574138

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В герметичной ПВХ изоляции_DN10-50мм_Цвет серый_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В герметичной ПВХ изоляции_DN10-50мм_Цвет серый_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В герметичной ПВХ изоляции_DN10-50мм_Цвет серый_DKC:...)
574101
574102
574104
574105
574109
574110
574114
574115
574119
574120
574124
574125
574129
574130
574134
574135
