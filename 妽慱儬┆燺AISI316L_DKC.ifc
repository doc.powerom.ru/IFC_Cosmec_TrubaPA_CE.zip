Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:13:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:13:34 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{0FC41033-5A15-4977-B62A-8CD5DC344563}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:13:34 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:13:34 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:13:34 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: М16х1,5, КНС_Гайка_AISI316L_DKC:М16х1,5:637947
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М16х1,5

# IfcFlowFitting: М20х1,5, КНС_Гайка_AISI316L_DKC:М20х1,5:637950
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М20х1,5

# IfcFlowFitting: М25х1,5, КНС_Гайка_AISI316L_DKC:М25х1,5:637953
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М25х1,5

# IfcFlowFitting: М32х1,5, КНС_Гайка_AISI316L_DKC:М32х1,5:637956
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М32х1,5

# IfcFlowFitting: М40х1,5, КНС_Гайка_AISI316L_DKC:М40х1,5:637959
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М40х1,5

# IfcFlowFitting: М50х1,5, КНС_Гайка_AISI316L_DKC:М50х1,5:637962
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М50х1,5
