Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:20:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:20:50 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{F316941B-47BB-481C-B1CB-249FF12B8F04}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:20:49 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:20:49 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:20:49 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: Муфта труба-труба (14)
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Муфта труба-труба
Name (КНС_МуфтаТруба-Труба_НикелированнаяЛатунь_DKC:Муфта труба-труба:...)
848927
848929
848933
848935
848939
848941
848943
848945
848949
848951
848955
848957
948649
948651

# IfcFlowFitting: Поворот на 90° (7)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Поворот на 90°
Name (КНС_ПоворотНа90ГрадусовИзОцинкованнойСтали_DKC:Поворот на 90°:...)
605163
605476
605485
605496
605507
605518
605527
