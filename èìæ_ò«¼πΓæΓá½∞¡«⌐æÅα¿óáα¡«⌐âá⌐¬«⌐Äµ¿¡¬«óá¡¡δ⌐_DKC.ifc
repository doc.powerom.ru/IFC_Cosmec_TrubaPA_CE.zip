Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:33:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:33:16 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{67A111BB-1714-4740-AA2B-78ABAA44C02F}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:33:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:33:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:33:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: D112-118, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D112-118:659292
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D112-118

# IfcFlowFitting: D18-24, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D18-24:659268
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D18-24

# IfcFlowFitting: D25-30, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D25-30:659271
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D25-30

# IfcFlowFitting: D30-36, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D30-36:659273
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D30-36

# IfcFlowFitting: D38-44, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D38-44:659275
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D38-44

# IfcFlowFitting: D44-50, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D44-50:659277
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D44-50

# IfcFlowFitting: D56-63, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D56-63:659279
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D56-63

# IfcFlowFitting: D75-80, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D75-80:659286
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D75-80

# IfcFlowFitting: D84-90, КНС_ХомутСтальнойСПриварнойГайкойОцинкованный_DKC:D84-90:659289
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D84-90
