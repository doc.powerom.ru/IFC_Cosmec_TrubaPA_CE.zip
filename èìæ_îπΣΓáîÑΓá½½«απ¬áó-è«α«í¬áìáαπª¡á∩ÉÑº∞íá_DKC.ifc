Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:06:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:06:39 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{2F69CC82-54E4-46E2-95D5-5D0824BC79A7}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:06:38 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:06:39 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:06:39 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 10 - М16х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 10 - М16х1.5:583647
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10 - М16х1.5

# IfcFlowFitting: DN 12 - М16х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 12 - М16х1.5:583655
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - М16х1.5

# IfcFlowFitting: DN 15 - М16х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 15 - М16х1.5:583657
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - М16х1.5

# IfcFlowFitting: DN 15 - М20х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 15 - М20х1.5:583659
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - М20х1.5

# IfcFlowFitting: DN 20 - М20х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 20 - М20х1.5:583661
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - М20х1.5

# IfcFlowFitting: DN 20 - М25х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 20 - М25х1.5:583663
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - М25х1.5

# IfcFlowFitting: DN 26 - М25х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 26 - М25х1.5:583665
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - М25х1.5

# IfcFlowFitting: DN 26 - М32х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 26 - М32х1.5:583667
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - М32х1.5

# IfcFlowFitting: DN 35 - М40х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 35 - М40х1.5:583669
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 35 - М40х1.5

# IfcFlowFitting: DN 40 - М40х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 40 - М40х1.5:583671
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - М40х1.5

# IfcFlowFitting: DN 40 - М50х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 40 - М50х1.5:583673
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - М50х1.5

# IfcFlowFitting: DN 50 - М50х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 50 - М50х1.5:583675
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - М50х1.5

# IfcFlowFitting: DN 50 - М63х1.5, КНС_МуфтаМеталлорукав-КоробкаНаружнаяРезьба_DKC:DN 50 - М63х1.5:583677
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - М63х1.5
