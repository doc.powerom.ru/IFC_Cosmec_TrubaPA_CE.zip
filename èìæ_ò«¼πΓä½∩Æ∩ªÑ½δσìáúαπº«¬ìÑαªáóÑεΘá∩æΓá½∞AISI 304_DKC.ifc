Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:31:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:31:51 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{7CEE3C8F-B280-4898-A74D-491BE1314033}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:31:50 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:31:50 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:31:50 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: D108–115_Сталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D108–115_Сталь AISI304:654885
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D108–115_Сталь AISI304

# IfcFlowFitting: D15-19_Сталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D15-19_Сталь AISI304:654824
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D15-19_Сталь AISI304

# IfcFlowFitting: D20-24_Cталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D20-24_Cталь AISI304:654810
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D20-24_Cталь AISI304

# IfcFlowFitting: D25-29_Cталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D25-29_Cталь AISI304:654813
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D25-29_Cталь AISI304

# IfcFlowFitting: D32-36_Сталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D32-36_Сталь AISI304:654815
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D32-36_Сталь AISI304

# IfcFlowFitting: D40-45_Cталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D40-45_Cталь AISI304:654817
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D40-45_Cталь AISI304

# IfcFlowFitting: D47-51_Cталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D47-51_Cталь AISI304:654819
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D47-51_Cталь AISI304

# IfcFlowFitting: D59-63_Cталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D59-63_Cталь AISI304:654821
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D59-63_Cталь AISI304

# IfcFlowFitting: D73-78_Cталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D73-78_Cталь AISI304:654863
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D73-78_Cталь AISI304

# IfcFlowFitting: D86-92_Cталь AISI304, КНС_ХомутДляТяжелыхНагрузокНержавеющаяСтальAISI 304_DKC:D86-92_Cталь AISI304:654879
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 304
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D86-92_Cталь AISI304
