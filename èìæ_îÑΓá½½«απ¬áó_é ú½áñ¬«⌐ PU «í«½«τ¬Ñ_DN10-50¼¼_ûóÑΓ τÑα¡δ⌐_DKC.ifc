Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T12:52:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 12:52:10 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{979FFB6F-2996-4955-8A60-B15F723F92A4}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 12:52:10 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 12:52:10 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 12:52:10 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_573041
2 x OutPort_573078
InPort_573042
InPort_573044
2 x OutPort_573046
InPort_573045
InPort_573049
2 x OutPort_573051
InPort_573050
InPort_573054
2 x OutPort_573056
InPort_573055
InPort_573059
2 x OutPort_573061
InPort_573060
InPort_573064
2 x OutPort_573066
InPort_573065
InPort_573069
2 x OutPort_573071
InPort_573070
InPort_573074
2 x OutPort_573076
InPort_573075

# IfcFlowFitting: Неспецифицируемый_Металлорукав в гладкой PU оболочке_черный (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в гладкой PU оболочке_черный
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в гладкой PU оболочке_черный:...)
573046
573051
573056
573061
573066
573071
573076
573078

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В гладкой PU оболочке_DN10-50мм_Цвет черный_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В гладкой PU оболочке_DN10-50мм_Цвет черный_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В гладкой PU оболочке_DN10-50мм_Цвет черный_DKC:...)
573041
573042
573044
573045
573049
573050
573054
573055
573059
573060
573064
573065
573069
573070
573074
573075
