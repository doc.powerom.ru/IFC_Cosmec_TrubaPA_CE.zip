Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:36:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:36:22 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{C874D0F9-42A3-4C69-AFB4-3F12E901E61A}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:36:22 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:36:22 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:36:22 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_580609
2 x OutPort_580723
InPort_580610
InPort_580611
2 x OutPort_580737
InPort_580612
InPort_580615
2 x OutPort_580745
InPort_580616
InPort_580619
2 x OutPort_580753
InPort_580620
InPort_580623
2 x OutPort_580761
InPort_580624
InPort_580627
2 x OutPort_580769
InPort_580628
InPort_580631
2 x OutPort_580777
InPort_580632
InPort_580635
2 x OutPort_580785
InPort_580636

# IfcFlowFitting: Неспецифицируемый_Гофрированная труба из ПА без протяжки_черный (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Гофрированная труба из ПА без протяжки_черный
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Гофрированная труба из ПА без протяжки_черный:...)
580723
580737
580745
580753
580761
580769
580777
580785

# IfcFlowSegment: Короб с соединительными деталями:КНС_Гофрированная труба_ПА_Без протяжки_DN7-48мм_Цвет черный_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Гофрированная труба_ПА_Без протяжки_DN7-48мм_Цвет черный_DKC
Name (Короб с соединительными деталями:КНС_Гофрированная труба_ПА_Без протяжки_DN7-48мм_Цвет черный_DKC:...)
580609
580610
580611
580612
580615
580616
580619
580620
580623
580624
580627
580628
580631
580632
580635
580636
