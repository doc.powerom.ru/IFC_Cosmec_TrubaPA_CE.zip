Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:44:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:44:43 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{28C65C35-B06E-467C-8357-96E94A1C7887}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:44:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:44:43 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:44:43 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 10-17, КНС_ДержательСРаздвижнойКрышкой_DKC:DN 10-17:696276
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10-17

# IfcFlowFitting: DN 23-29, КНС_ДержательСРаздвижнойКрышкой_DKC:DN 23-29:696288
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 23-29

# IfcFlowFitting: DN 36-48, КНС_ДержательСРаздвижнойКрышкой_DKC:DN 36-48:696290
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 36-48
