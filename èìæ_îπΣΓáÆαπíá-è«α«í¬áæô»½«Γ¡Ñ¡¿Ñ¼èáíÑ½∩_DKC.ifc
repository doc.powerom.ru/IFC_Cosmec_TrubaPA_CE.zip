Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:24:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:24:36 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{9B525377-AAF1-44C7-8D2B-88D72DC7E01C}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:24:36 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:24:36 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:24:36 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 16 - M12x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 16 - M12x1,5:615267
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 16 - M12x1,5

# IfcFlowFitting: DN 16 - M16x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 16 - M16x1,5:615269
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 16 - M16x1,5

# IfcFlowFitting: DN 16 - M20x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 16 - M20x1,5:615271
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 16 - M20x1,5

# IfcFlowFitting: DN 20 - M16x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 20 - M16x1,5:615273
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M16x1,5

# IfcFlowFitting: DN 20 - M20x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 20 - M20x1,5:615275
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M20x1,5

# IfcFlowFitting: DN 20 - M25x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 20 - M25x1,5:615277
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M25x1,5

# IfcFlowFitting: DN 25 - M20x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 25 - M20x1,5:615279
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 25 - M20x1,5

# IfcFlowFitting: DN 25 - M25x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 25 - M25x1,5:615340
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 25 - M25x1,5

# IfcFlowFitting: DN 25 - M32x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 25 - M32x1,5:615356
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 25 - M32x1,5

# IfcFlowFitting: DN 32 - M25x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 32 - M25x1,5:615362
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 32 - M25x1,5

# IfcFlowFitting: DN 32 - M32x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 32 - M32x1,5:615368
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 32 - M32x1,5

# IfcFlowFitting: DN 32 - M40x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 32 - M40x1,5:615374
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 32 - M40x1,5

# IfcFlowFitting: DN 40 - M32x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 40 - M32x1,5:615380
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M32x1,5

# IfcFlowFitting: DN 40 - M40x1,5, КНС_МуфтаТруба-КоробкаСУплотнениемКабеля_DKC:DN 40 - M40x1,5:615386
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M40x1,5
