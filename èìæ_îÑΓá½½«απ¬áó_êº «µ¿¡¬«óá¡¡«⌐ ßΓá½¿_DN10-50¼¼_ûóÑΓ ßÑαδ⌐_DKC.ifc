Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:01:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:01:52 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{CD2B37D6-331B-4E89-B27E-31F8EC556CF8}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:01:52 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:01:52 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:01:52 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_578236
2 x OutPort_578273
InPort_578237
InPort_578239
2 x OutPort_578241
InPort_578240
InPort_578244
2 x OutPort_578246
InPort_578245
InPort_578249
2 x OutPort_578251
InPort_578250
InPort_578254
2 x OutPort_578256
InPort_578255
InPort_578259
2 x OutPort_578261
InPort_578260
InPort_578264
2 x OutPort_578266
InPort_578265
InPort_578269
2 x OutPort_578271
InPort_578270

# IfcFlowFitting: Неспецифицируемый_Металлорукав из оцинкованной стали_серый (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав из оцинкованной стали_серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав из оцинкованной стали_серый:...)
578241
578246
578251
578256
578261
578266
578271
578273

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_Из оцинкованной стали_DN10-50мм_Цвет серый_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_Из оцинкованной стали_DN10-50мм_Цвет серый_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_Из оцинкованной стали_DN10-50мм_Цвет серый_DKC:...)
578236
578237
578239
578240
578244
578245
578249
578250
578254
578255
578259
578260
578264
578265
578269
578270
