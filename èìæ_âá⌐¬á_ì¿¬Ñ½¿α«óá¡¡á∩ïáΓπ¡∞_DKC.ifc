Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:13:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:13:56 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{A86CDACA-BD04-4689-B710-70E9EC549CDD}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:13:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:13:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:13:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: М12х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М12х1,5:639917
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М12х1,5

# IfcFlowFitting: М16х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М16х1,5:638233
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М16х1,5

# IfcFlowFitting: М20х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М20х1,5:638236
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М20х1,5

# IfcFlowFitting: М25х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М25х1,5:638239
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М25х1,5

# IfcFlowFitting: М32х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М32х1,5:638242
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М32х1,5

# IfcFlowFitting: М40х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М40х1,5:638245
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М40х1,5

# IfcFlowFitting: М50х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М50х1,5:638248
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М50х1,5

# IfcFlowFitting: М63х1,5, КНС_Гайка_НикелированнаяЛатунь_DKC:М63х1,5:639933
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М63х1,5
