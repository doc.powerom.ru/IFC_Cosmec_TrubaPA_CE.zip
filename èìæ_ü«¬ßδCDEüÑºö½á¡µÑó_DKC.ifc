Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:49:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:49:20 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{A2B730FD-9C53-4F9C-9BCA-3340E6417C74}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:49:19 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:49:19 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:49:19 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 150 x 150 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:150 x 150 x 120 мм:702426
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 150 x 150 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE11120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE11120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 150 x 150 x 80 мм, КНС_БоксыCDEБезФланцев_DKC:150 x 150 x 80 мм:702496
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 150 x 150 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE1180; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE1180/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 200 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:200 x 200 x 120 мм:702514
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 200 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE22120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE22120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 200 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_DKC:200 x 200 x 80 мм:702520
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 200 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE2280; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE2280/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 150 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:300 x 150 x 120 мм:702526
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 150 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE31120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE31120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:300 x 200 x 120 мм:702532
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE32120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE32120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_DKC:300 x 200 x 80 мм:702538
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE3280; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE3280/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:300 x 300 x 120 мм:702544
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE33120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE33120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:400 x 200 x 120 мм:702550
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE42120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE42120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_DKC:400 x 200 x 80 мм:702556
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE4280; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE4280/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:400 x 300 x 120 мм:702562
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE43120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE43120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 400 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:400 x 400 x 120 мм:702568
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 400 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE44120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE44120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:500 x 200 x 120 мм:702574
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE52120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE52120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:500 x 300 x 120 мм:702580
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE53120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE53120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:600 x 200 x 120 мм:702586
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE62120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE62120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_DKC:600 x 200 x 80 мм:702592
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE6280; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE6280/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 300 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:600 x 300 x 120 мм:702598
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 300 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE63120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE63120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 400 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:600 x 400 x 120 мм:702604
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 400 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE64120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE64120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 200 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:800 x 200 x 120 мм:702610
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 200 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE82120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE82120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 200 x 80 мм, КНС_БоксыCDEБезФланцев_DKC:800 x 200 x 80 мм:702616
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 200 x 80 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE8280; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE8280/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 400 x 120 мм, КНС_БоксыCDEБезФланцев_DKC:800 x 400 x 120 мм:702622
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 400 x 120 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CDE84120; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CDE84120/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для систем распределения электроэнергии и автоматизации технологических процессов. Материал: • каркас и дверь: листовая сталь 1,5 мм; • уплотнитель на двери: полиуретан. Отличительные особенности: • степень пыле- и влагозащиты до IP66; • степень ударопрочности – IK10. Комплект поставки: • корпус, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус

# IfcFlowFitting: 150x150 мм (3)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 150x150 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:150x150 мм:...)
702428
702498
702618

# IfcFlowFitting: 200x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 200x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:200x200 мм:...)
702516
702522

# IfcFlowFitting: 300x150 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x150 мм:702528
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x150 мм

# IfcFlowFitting: 300x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x200 мм:...)
702534
702540

# IfcFlowFitting: 300x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:300x300 мм:702546
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 300x300 мм

# IfcFlowFitting: 400x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x200 мм:...)
702552
702558

# IfcFlowFitting: 400x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x300 мм:702564
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x300 мм

# IfcFlowFitting: 400x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:400x400 мм:702570
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400x400 мм

# IfcFlowFitting: 500x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:500x200 мм:702576
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 500x200 мм

# IfcFlowFitting: 500x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:500x300 мм:702582
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 500x300 мм

# IfcFlowFitting: 600x200 мм (2)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x200 мм
Name (КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x200 мм:...)
702588
702594

# IfcFlowFitting: 600x300 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x300 мм:702600
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x300 мм

# IfcFlowFitting: 600x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:600x400 мм:702606
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600x400 мм

# IfcFlowFitting: 800x200 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:800x200 мм:702612
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 800x200 мм

# IfcFlowFitting: 800x400 мм, КНС_ПлатаМонтажнаяДляКорпусовCDE_DKC:800x400 мм:702624
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 800x400 мм
