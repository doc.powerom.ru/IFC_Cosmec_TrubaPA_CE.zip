Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:00:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:00:35 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{22D537E9-479C-4207-BEC8-0CF214CC77D1}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:00:35 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:00:35 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:00:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_577318
2 x OutPort_577355
InPort_577319
InPort_577321
2 x OutPort_577323
InPort_577322
InPort_577326
2 x OutPort_577328
InPort_577327
InPort_577331
2 x OutPort_577333
InPort_577332
InPort_577336
2 x OutPort_577338
InPort_577337
InPort_577341
2 x OutPort_577343
InPort_577342
InPort_577346
2 x OutPort_577348
InPort_577347
InPort_577351
2 x OutPort_577353
InPort_577352

# IfcFlowFitting: Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции в оплетке из оцинкованной стали_серый (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции в оплетке из оцинкованной стали_серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции в оплетке из оцинкованной стали_серый:...)
577323
577328
577333
577338
577343
577348
577353
577355

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В герметичной ПВХ изоляции в оплетке из оцинкованной стали_DN10-50мм_Цвет серый_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В герметичной ПВХ изоляции в оплетке из оцинкованной стали_DN10-50мм_Цвет серый_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В герметичной ПВХ изоляции в оплетке из оцинкованной стали_DN10-50мм_Цвет серый_DKC:...)
577318
577319
577321
577322
577326
577327
577331
577332
577336
577337
577341
577342
577346
577347
577351
577352
