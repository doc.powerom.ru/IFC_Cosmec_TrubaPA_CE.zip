Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:42:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:42:18 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{524B8FF5-843E-4AB5-9CB4-791BF91D973A}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:42:18 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:42:18 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:42:18 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: M16х1,5, КНС_ВтулкаСоединительная_ГофрированныеТрубы_DKC:M16х1,5:687694
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5

# IfcFlowFitting: M20х1,5, КНС_ВтулкаСоединительная_ГофрированныеТрубы_DKC:M20х1,5:687696
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5

# IfcFlowFitting: M25х1,5, КНС_ВтулкаСоединительная_ГофрированныеТрубы_DKC:M25х1,5:687698
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5

# IfcFlowFitting: M32х1,5, КНС_ВтулкаСоединительная_ГофрированныеТрубы_DKC:M32х1,5:687700
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M32х1,5

# IfcFlowFitting: M40х1,5, КНС_ВтулкаСоединительная_ГофрированныеТрубы_DKC:M40х1,5:687702
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5

# IfcFlowFitting: M50х1,5, КНС_ВтулкаСоединительная_ГофрированныеТрубы_DKC:M50х1,5:687709
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5

# IfcFlowFitting: M63х1,5, КНС_ВтулкаСоединительная_ГофрированныеТрубы_DKC:M63х1,5:687937
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M63х1,5
