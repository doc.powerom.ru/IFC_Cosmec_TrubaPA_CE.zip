Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:16:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:16:30 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{A838AB4F-B73D-4FBD-A605-2F43FD02836C}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:16:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:16:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:16:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: М16х1,5 ,IP55, 118х51х42мм, КНС_КоробкаПротяжнаяАлюминиевая_2Ввода_DKC:М16х1,5 ,IP55, 118х51х42мм:632021
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М16х1,5 ,IP55, 118х51х42мм

# IfcFlowFitting: М20х1,5 ,IP55, 118х51х42мм, КНС_КоробкаПротяжнаяАлюминиевая_2Ввода_DKC:М20х1,5 ,IP55, 118х51х42мм:632173
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М20х1,5 ,IP55, 118х51х42мм

# IfcFlowFitting: М25х1,5 ,IP55, 118х51х42мм, КНС_КоробкаПротяжнаяАлюминиевая_2Ввода_DKC:М25х1,5 ,IP55, 118х51х42мм:632202
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М25х1,5 ,IP55, 118х51х42мм

# IfcFlowFitting: М32х1,5 ,IP55, 146х45х57мм, КНС_КоробкаПротяжнаяАлюминиевая_2Ввода_DKC:М32х1,5 ,IP55, 146х45х57мм:632208
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М32х1,5 ,IP55, 146х45х57мм

# IfcFlowFitting: М40х1,5 ,IP55, 171х62х71мм, КНС_КоробкаПротяжнаяАлюминиевая_2Ввода_DKC:М40х1,5 ,IP55, 171х62х71мм:632214
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М40х1,5 ,IP55, 171х62х71мм

# IfcFlowFitting: М50х1,5 ,IP55, 171х62х71мм, КНС_КоробкаПротяжнаяАлюминиевая_2Ввода_DKC:М50х1,5 ,IP55, 171х62х71мм:632220
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М50х1,5 ,IP55, 171х62х71мм
