Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:11:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:11:52 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{FBDB0EAB-87B3-448E-AB90-D6C32D530C8E}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:11:51 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:11:51 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:11:51 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: муфта DN 10 - DN16 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 10 - DN16 стальная труба:599678
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 10 - DN16 стальная труба

# IfcFlowFitting: муфта DN 12 - DN16 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 12 - DN16 стальная труба:599681
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 12 - DN16 стальная труба

# IfcFlowFitting: муфта DN 15 - DN16 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 15 - DN16 стальная труба:599683
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 15 - DN16 стальная труба

# IfcFlowFitting: муфта DN 20 - DN20 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 20 - DN20 стальная труба:599703
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 20 - DN20 стальная труба

# IfcFlowFitting: муфта DN 20 - DN25 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 20 - DN25 стальная труба:599685
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 20 - DN25 стальная труба

# IfcFlowFitting: муфта DN 26 - DN32 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 26 - DN32 стальная труба:599687
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 26 - DN32 стальная труба

# IfcFlowFitting: муфта DN 35 - DN32 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 35 - DN32 стальная труба:599689
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 35 - DN32 стальная труба

# IfcFlowFitting: муфта DN 35 - DN40 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 35 - DN40 стальная труба:599706
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 35 - DN40 стальная труба

# IfcFlowFitting: муфта DN 40 - DN40 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 40 - DN40 стальная труба:599691
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 40 - DN40 стальная труба

# IfcFlowFitting: муфта DN 40 - DN50 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 40 - DN50 стальная труба:599693
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 40 - DN50 стальная труба

# IfcFlowFitting: муфта DN 50 - DN50 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГерметичнойИзоляции-СтальнаяТруба_DKC:муфта DN 50 - DN50 стальная труба:599709
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 50 - DN50 стальная труба
