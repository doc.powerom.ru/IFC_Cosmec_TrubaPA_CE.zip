Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T12:57:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 12:57:13 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{B0F56BB4-3092-4A74-941C-4D5693F02140}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 12:57:13 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 12:57:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 12:57:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_576535
2 x OutPort_576572
InPort_576536
InPort_576538
2 x OutPort_576540
InPort_576539
InPort_576543
2 x OutPort_576545
InPort_576544
InPort_576548
2 x OutPort_576550
InPort_576549
InPort_576553
2 x OutPort_576555
InPort_576554
InPort_576558
2 x OutPort_576560
InPort_576559
InPort_576563
2 x OutPort_576565
InPort_576564
InPort_576568
2 x OutPort_576570
InPort_576569

# IfcFlowFitting: Неспецифицируемый_Металлорукав в гладкой ПВХ изоляции_серый (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в гладкой ПВХ изоляции_серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в гладкой ПВХ изоляции_серый:...)
576540
576545
576550
576555
576560
576565
576570
576572

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В гладкой ПВХ изоляции_DN10-50мм_Цвет серый_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В гладкой ПВХ изоляции_DN10-50мм_Цвет серый_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В гладкой ПВХ изоляции_DN10-50мм_Цвет серый_DKC:...)
576535
576536
576538
576539
576543
576544
576548
576549
576553
576554
576558
576559
576563
576564
576568
576569
