Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:03:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:03:09 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{6D4D2969-5F0D-43BC-AC8E-AD547BCF882C}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:03:08 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:03:08 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:03:08 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_578007
2 x OutPort_578044
InPort_578008
InPort_578010
2 x OutPort_578012
InPort_578011
InPort_578015
2 x OutPort_578017
InPort_578016
InPort_578020
2 x OutPort_578022
InPort_578021
InPort_578025
2 x OutPort_578027
InPort_578026
InPort_578030
2 x OutPort_578032
InPort_578031
InPort_578035
2 x OutPort_578037
InPort_578036
InPort_578040
2 x OutPort_578042
InPort_578041

# IfcFlowFitting: Неспецифицируемый_Металлорукав в гладкой EVA изоляции и оплетке из нержавейщей стали_серый (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в гладкой EVA изоляции и оплетке из нержавейщей стали_серый
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в гладкой EVA изоляции и оплетке из нержавейщей стали_серый:...)
578012
578017
578022
578027
578032
578037
578042
578044

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В гладкой EVA изоляции в оплетке из оцинкованной стали_DN10-50мм_Цвет серый_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В гладкой EVA изоляции в оплетке из оцинкованной стали_DN10-50мм_Цвет серый_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В гладкой EVA изоляции в оплетке из оцинкованной стали_DN10-50мм_Цвет серый_DKC:...)
578007
578008
578010
578011
578015
578016
578020
578021
578025
578026
578030
578031
578035
578036
578040
578041
