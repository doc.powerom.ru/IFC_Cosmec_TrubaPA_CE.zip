Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:15:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:15:17 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{0FA20A34-AB13-4FC9-9209-5910DC89D904}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:15:17 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:15:17 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:15:17 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: 128х103х55мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашенная_DKC:128х103х55мм:553567
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 128х103х55мм

# IfcFlowFitting: 154х129х58мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашенная_DKC:154х129х58мм:553569
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 154х129х58мм

# IfcFlowFitting: 178х155х74мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашенная_DKC:178х155х74мм:553571
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 178х155х74мм

# IfcFlowFitting: 239х202х85мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашенная_DKC:239х202х85мм:553573
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 239х202х85мм

# IfcFlowFitting: 294х244х114мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашенная_DKC:294х244х114мм:553575
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 294х244х114мм

# IfcFlowFitting: 392х298х144мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашенная_DKC:392х298х144мм:553602
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 392х298х144мм

# IfcFlowFitting: 90х90х53мм, КНС_КоробкаОтветвительнаяАлюминиеваяОкрашенная_DKC:90х90х53мм:553564
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 90х90х53мм
