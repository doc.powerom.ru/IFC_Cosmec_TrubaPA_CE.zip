Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:20:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:20:15 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{5C0DC455-DA2E-4550-8F96-B4220AD364D3}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:20:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:20:15 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:20:15 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: Муфта труба-труба (10)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Муфта труба-труба
Name (КНС_МуфтаТруба-Труба_AISI316L_DKC:Муфта труба-труба:...)
846395
846397
846401
846403
846407
846409
846413
846415
859473
859475

# IfcFlowFitting: Поворот на 90° (5)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Поворот на 90°
Name (КНС_ПоворотНа90ГрадусовИзНержавеющейСталиAISI316L_DKC:Поворот на 90°:...)
605634
605636
605638
605640
605642
