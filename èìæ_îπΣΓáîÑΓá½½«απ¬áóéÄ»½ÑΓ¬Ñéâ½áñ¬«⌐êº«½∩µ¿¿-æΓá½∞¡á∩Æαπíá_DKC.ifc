Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:11:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:11:29 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{D4984CC7-023B-4348-BEE1-F3408A0FA1B0}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:11:29 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:11:29 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:11:29 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: муфта DN 10 - DN16 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 10 - DN16 стальная труба:599643
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 10 - DN16 стальная труба

# IfcFlowFitting: муфта DN 12 - DN16 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 12 - DN16 стальная труба:599646
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 12 - DN16 стальная труба

# IfcFlowFitting: муфта DN 15 - DN16 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 15 - DN16 стальная труба:599648
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 15 - DN16 стальная труба

# IfcFlowFitting: муфта DN 20 - DN20 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 20 - DN20 стальная труба:599668
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 20 - DN20 стальная труба

# IfcFlowFitting: муфта DN 20 - DN25 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 20 - DN25 стальная труба:599650
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 20 - DN25 стальная труба

# IfcFlowFitting: муфта DN 26 - DN32 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 26 - DN32 стальная труба:599652
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 26 - DN32 стальная труба

# IfcFlowFitting: муфта DN 35 - DN32 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 35 - DN32 стальная труба:599654
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 35 - DN32 стальная труба

# IfcFlowFitting: муфта DN 35 - DN40 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 35 - DN40 стальная труба:601874
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 35 - DN40 стальная труба

# IfcFlowFitting: муфта DN 40 - DN40 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 40 - DN40 стальная труба:599671
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 40 - DN40 стальная труба

# IfcFlowFitting: муфта DN 40 - DN50 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 40 - DN50 стальная труба:599656
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 40 - DN50 стальная труба

# IfcFlowFitting: муфта DN 50 - DN50 стальная труба, КНС_МуфтаМеталлорукавВОплеткеВГладкойИзоляции-СтальнаяТруба_DKC:муфта DN 50 - DN50 стальная труба:599658
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: муфта DN 50 - DN50 стальная труба
