Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:39:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:39:06 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{EC31024A-49AE-4483-8FA1-CF2447E0E3D7}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:39:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:39:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:39:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 10 - M16x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 10 - M16x1,5:664884
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10 - M16x1,5

# IfcFlowFitting: DN 12 - M16x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 12 - M16x1,5:664886
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - M16x1,5

# IfcFlowFitting: DN 12 - M20x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 12 - M20x1,5:664888
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - M20x1,5

# IfcFlowFitting: DN 17 - M20x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 17 - M20x1,5:664890
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 17 - M20x1,5

# IfcFlowFitting: DN 23 - M25x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 23 - M25x1,5:664892
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 23 - M25x1,5

# IfcFlowFitting: DN 29 - M32x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 29 - M32x1,5:664894
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 29 - M32x1,5

# IfcFlowFitting: DN 36 - M40x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 36 - M40x1,5:664896
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 36 - M40x1,5

# IfcFlowFitting: DN 48 - M50x1,5, КНС_Муфта90°Труба-Коробка_DKC:DN 48 - M50x1,5:666633
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 48 - M50x1,5
