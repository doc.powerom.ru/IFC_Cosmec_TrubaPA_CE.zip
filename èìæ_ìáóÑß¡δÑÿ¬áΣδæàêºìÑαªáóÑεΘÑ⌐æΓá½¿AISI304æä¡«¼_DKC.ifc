Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:45:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:45:23 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{975892DE-BD9B-47B5-84C8-767BA548B757}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:45:22 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:45:22 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:45:22 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 1000 x 600 x 250мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1000 x 600 x 250мм:717177
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1000 x 600 x 250мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB10691; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB10691/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 x 600 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1000 x 600 x 300мм:717179
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1000 x 600 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB10631; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB10631/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 x 600 x 400мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1000 x 600 x 400мм:717181
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1000 x 600 x 400мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB10641; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB10641/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 x 800 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1000 x 800 x 300мм:717183
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1000 x 800 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB10831; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB10831/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1000 x 800 x 400мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1000 x 800 x 400мм:717185
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1000 x 800 x 400мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB10841; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB10841/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1200 x 600 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1200 x 600 x 300мм:717187
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1200 x 600 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB12631; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB12631/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1200 x 800 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1200 x 800 x 300мм:717189
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1200 x 800 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB12831; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB12831/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1400 x 600 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1400 x 600 x 300мм:717224
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1400 x 600 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB14631; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB14631/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1400 x 800 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:1400 x 800 x 300мм:717226
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 1400 x 800 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB14831; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB14831/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 250 x 150мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:300 x 250 x 150мм:716888
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 250 x 150мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB03911; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB03911/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 300 x 150мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:300 x 300 x 150мм:716892
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 300 x 150мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB03311; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB03311/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 300 x 400 x 150мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:300 x 400 x 150мм:716896
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 300 x 400 x 150мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB03411; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB03411/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 300 x 150мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:400 x 300 x 150мм:716900
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 300 x 150мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB04311; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB04311/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 300 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:400 x 300 x 200мм:716904
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 300 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB04321; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB04321/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 400 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:400 x 400 x 200мм:716908
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 400 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB04421; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB04421/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 400 x 600 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:400 x 600 x 200мм:716912
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 400 x 600 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB04621; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB04621/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 300 x 150мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:500 x 300 x 150мм:716916
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 300 x 150мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB05311; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB05311/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 300 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:500 x 300 x 200мм:716920
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 300 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB05321; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB05321/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 400 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:500 x 400 x 200мм:716924
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 400 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB05421; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB05421/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 400 x 250мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:500 x 400 x 250мм:716928
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 400 x 250мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB05491; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB05491/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 500 x 500 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:500 x 500 x 200мм:716932
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 500 x 500 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB05521; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB05521/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 400 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:600 x 400 x 200мм:716936
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 400 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB06421; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB06421/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 400 x 250мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:600 x 400 x 250мм:716940
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 400 x 250мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB06491; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB06491/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 400 x 400мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:600 x 400 x 400мм:716944
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 400 x 400мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB06441; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB06441/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 600 x 250мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:600 x 600 x 250мм:716948
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 600 x 250мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB06691; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB06691/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 x 600 x 400мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:600 x 600 x 400мм:716952
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 600 x 600 x 400мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB06641; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB06641/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 700 x 500 x 200мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:700 x 500 x 200мм:716956
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 700 x 500 x 200мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB07521; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB07521/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 700 x 500 x 250мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:700 x 500 x 250мм:716960
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 700 x 500 x 250мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB07591; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB07591/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 600 x 250мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:800 x 600 x 250мм:716964
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 600 x 250мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB08691; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB08691/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 600 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:800 x 600 x 300мм:716968
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 600 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB08631; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB08631/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 600 x 400мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:800 x 600 x 400мм:717171
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 600 x 400мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB08641; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB08641/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 800 x 300мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:800 x 800 x 300мм:717173
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 800 x 300мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB08831; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB08831/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 x 800 x 400мм, КНС_НавесныеШкафыСЕИзНержавеющейСталиAISI304СДном_DKC:800 x 800 x 400мм:717175
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 800 x 800 x 400мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB08841; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB08841/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP66; • степень ударопрочности – IK10; • дверь реверсивная, по умолчанию установлена с правой стороны; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка.; Комментарии к типоразмеру: Металлический корпус
