Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T12:58:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 12:58:03 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{03380522-0D8C-4AFA-9DD4-FD9BBAA250C5}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 12:58:03 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 12:58:03 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 12:58:03 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_577190
2 x OutPort_577227
InPort_577191
InPort_577193
2 x OutPort_577195
InPort_577194
InPort_577198
2 x OutPort_577200
InPort_577199
InPort_577203
2 x OutPort_577205
InPort_577204
InPort_577208
2 x OutPort_577210
InPort_577209
InPort_577213
2 x OutPort_577215
InPort_577214
InPort_577218
2 x OutPort_577220
InPort_577219
InPort_577223
2 x OutPort_577225
InPort_577224

# IfcFlowFitting: Неспецифицируемый_Металлорукав в гладкой ПВХ изоляции_черный (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в гладкой ПВХ изоляции_черный
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в гладкой ПВХ изоляции_черный:...)
577195
577200
577205
577210
577215
577220
577225
577227

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В гладкой ПВХ изоляции_DN10-50мм_Цвет черный_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В гладкой ПВХ изоляции_DN10-50мм_Цвет черный_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В гладкой ПВХ изоляции_DN10-50мм_Цвет черный_DKC:...)
577190
577191
577193
577194
577198
577199
577203
577204
577208
577209
577213
577214
577218
577219
577223
577224
