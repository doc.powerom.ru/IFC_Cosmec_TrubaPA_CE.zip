Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:32:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:32:53 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{751B7132-D2AE-483A-BD5D-CE41D1348BA4}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:32:53 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:32:53 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:32:53 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: D16, КНС_ХомутСтальнойОцинкованный_DKC:D16:657803
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D16

# IfcFlowFitting: D20, КНС_ХомутСтальнойОцинкованный_DKC:D20:657806
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D20

# IfcFlowFitting: D25, КНС_ХомутСтальнойОцинкованный_DKC:D25:657808
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D25

# IfcFlowFitting: D32, КНС_ХомутСтальнойОцинкованный_DKC:D32:657810
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D32

# IfcFlowFitting: D40, КНС_ХомутСтальнойОцинкованный_DKC:D40:657812
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D40

# IfcFlowFitting: D50, КНС_ХомутСтальнойОцинкованный_DKC:D50:657880
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D50

# IfcFlowFitting: D63, КНС_ХомутСтальнойОцинкованный_DKC:D63:658051
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D63

# IfcOpeningElement: Opening (7)
In: Этаж 01
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Name (КНС_ХомутСтальнойОцинкованный_DKC:...)
D16:657803:1
D20:657806:1
D25:657808:1
D32:657810:1
D40:657812:1
D50:657880:1
D63:658051:1
