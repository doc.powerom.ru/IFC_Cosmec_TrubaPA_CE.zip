Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T12:56:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 12:56:45 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{A0B9DDD8-EECF-4AD6-9023-53B425D7B44D}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 12:56:45 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 12:56:45 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 12:56:45 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_576350
2 x OutPort_576387
InPort_576351
InPort_576353
2 x OutPort_576355
InPort_576354
InPort_576358
2 x OutPort_576360
InPort_576359
InPort_576363
2 x OutPort_576365
InPort_576364
InPort_576368
2 x OutPort_576370
InPort_576369
InPort_576373
2 x OutPort_576375
InPort_576374
InPort_576378
2 x OutPort_576380
InPort_576379
InPort_576383
2 x OutPort_576385
InPort_576384

# IfcFlowFitting: Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции_черный (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции_черный
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в герметичной ПВХ изоляции_черный:...)
576355
576360
576365
576370
576375
576380
576385
576387

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В герметичной ПВХ изоляции_DN10-50мм_Цвет черный_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В герметичной ПВХ изоляции_DN10-50мм_Цвет черный_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В герметичной ПВХ изоляции_DN10-50мм_Цвет черный_DKC:...)
576350
576351
576353
576354
576358
576359
576363
576364
576368
576369
576373
576374
576378
576379
576383
576384
