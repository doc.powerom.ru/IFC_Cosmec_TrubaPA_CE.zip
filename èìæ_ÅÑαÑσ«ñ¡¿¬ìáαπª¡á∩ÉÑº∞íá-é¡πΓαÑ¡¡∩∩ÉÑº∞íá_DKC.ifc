Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:31:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:31:24 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{F29711F3-137B-4ECD-9447-1CA1464A2E0A}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:31:24 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:31:24 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:31:24 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: Переходник 1" (наружн. резьба)/ M20x1,5 (внутр. резьба),GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 1" (наружн. резьба)/ M20x1,5 (внутр. резьба),GAS-MET:646853
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 1" (наружн. резьба)/ M20x1,5 (внутр. резьба),GAS-MET

# IfcFlowFitting: Переходник 1" (наружн. резьба)/ M25x1,5 (внутр. резьба),GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 1" (наружн. резьба)/ M25x1,5 (внутр. резьба),GAS-MET:646863
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 1" (наружн. резьба)/ M25x1,5 (внутр. резьба),GAS-MET

# IfcFlowFitting: Переходник 1" (наружн. резьба)/ M32x1,5 (внутр. резьба),GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 1" (наружн. резьба)/ M32x1,5 (внутр. резьба),GAS-MET:647403
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 1" (наружн. резьба)/ M32x1,5 (внутр. резьба),GAS-MET

# IfcFlowFitting: Переходник 1" 1/2 (наружн. резьба)/ M40x1,5 (внутр. резьба), GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 1" 1/2 (наружн. резьба)/ M40x1,5 (внутр. резьба), GAS-MET:646865
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 1" 1/2 (наружн. резьба)/ M40x1,5 (внутр. резьба), GAS-MET

# IfcFlowFitting: Переходник 1" 1/4 (наружн. резьба)/ M32x1,5 (внутр. резьба), GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 1" 1/4 (наружн. резьба)/ M32x1,5 (внутр. резьба), GAS-MET:646867
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 1" 1/4 (наружн. резьба)/ M32x1,5 (внутр. резьба), GAS-MET

# IfcFlowFitting: Переходник 1/2" (наружн. резьба)/ M16x1,5 (внутр. резьба), GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 1/2" (наружн. резьба)/ M16x1,5 (внутр. резьба), GAS-MET:646869
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 1/2" (наружн. резьба)/ M16x1,5 (внутр. резьба), GAS-MET

# IfcFlowFitting: Переходник 2" (наружн. резьба)/ M50x1,5 (внутр. резьба),GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 2" (наружн. резьба)/ M50x1,5 (внутр. резьба),GAS-MET:646871
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 2" (наружн. резьба)/ M50x1,5 (внутр. резьба),GAS-MET

# IfcFlowFitting: Переходник 2" (наружн. резьба)/ M63x1,5 (внутр. резьба),GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 2" (наружн. резьба)/ M63x1,5 (внутр. резьба),GAS-MET:646873
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 2" (наружн. резьба)/ M63x1,5 (внутр. резьба),GAS-MET

# IfcFlowFitting: Переходник 2" 1/2 (наружн. резьба)/ M63x1,5 (внутр. резьба), GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 2" 1/2 (наружн. резьба)/ M63x1,5 (внутр. резьба), GAS-MET:647622
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 2" 1/2 (наружн. резьба)/ M63x1,5 (внутр. резьба), GAS-MET

# IfcFlowFitting: Переходник 3/4" (наружн. резьба)/ M20x1,5 (внутр. резьба), GAS-MET, КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник 3/4" (наружн. резьба)/ M20x1,5 (внутр. резьба), GAS-MET:646875
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник 3/4" (наружн. резьба)/ M20x1,5 (внутр. резьба), GAS-MET

# IfcFlowFitting: Переходник M16x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M16x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба):646879
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M16x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M20x1,5 (наружн. резьба)/ M16x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M20x1,5 (наружн. резьба)/ M16x1,5 (внутр. резьба):646881
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M20x1,5 (наружн. резьба)/ M16x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M20x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M20x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба):646883
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M20x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M25x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M25x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба):646885
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M25x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M25x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M25x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба):646887
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M25x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M32x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M32x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба):647175
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M32x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M32x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M32x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба):647198
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M32x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M32x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M32x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба):647202
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M32x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M40x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M40x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба):647206
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M40x1,5 (наружн. резьба)/ M20x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M40x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M40x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба):647210
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M40x1,5 (наружн. резьба)/ M25x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M40x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M40x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба):647214
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M40x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M40x1,5 (наружн. резьба)/ M50x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M40x1,5 (наружн. резьба)/ M50x1,5 (внутр. резьба):647218
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M40x1,5 (наружн. резьба)/ M50x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M50x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M50x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба):647222
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M50x1,5 (наружн. резьба)/ M32x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M50x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M50x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба):647226
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M50x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M50x1,5 (наружн. резьба)/ M63x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M50x1,5 (наружн. резьба)/ M63x1,5 (внутр. резьба):647230
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M50x1,5 (наружн. резьба)/ M63x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M63x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M63x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба):647234
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M63x1,5 (наружн. резьба)/ M40x1,5 (внутр. резьба)

# IfcFlowFitting: Переходник M63x1,5 (наружн. резьба)/ M50x1,5 (внутр. резьба), КНС_ПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник M63x1,5 (наружн. резьба)/ M50x1,5 (внутр. резьба):647238
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник M63x1,5 (наружн. резьба)/ M50x1,5 (внутр. резьба)
