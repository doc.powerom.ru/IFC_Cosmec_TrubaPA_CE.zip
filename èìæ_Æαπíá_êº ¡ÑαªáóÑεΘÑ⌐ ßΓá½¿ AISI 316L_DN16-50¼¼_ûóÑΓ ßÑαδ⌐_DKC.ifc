Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:18:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:18:38 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{5C257A23-8B0D-47BF-A69C-58B797296461}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:18:37 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:18:37 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:18:37 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowSegment: Короб с соединительными деталями:КНС_Труба_Из нержавеющей стали AISI 316L_DN16-50мм_Цвет серый_DKC (6)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Труба_Из нержавеющей стали AISI 316L_DN16-50мм_Цвет серый_DKC
Name (Короб с соединительными деталями:КНС_Труба_Из нержавеющей стали AISI 316L_DN16-50мм_Цвет серый_DKC:...)
578750
578752
578754
578756
578758
578760
