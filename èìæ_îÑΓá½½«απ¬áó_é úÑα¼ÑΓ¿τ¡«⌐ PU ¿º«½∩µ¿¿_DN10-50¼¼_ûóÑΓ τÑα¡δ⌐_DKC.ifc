Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T12:51:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 12:51:03 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{DD03FFE7-D0C0-4D43-9C1A-340DC3FBE421}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 12:51:02 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 12:51:02 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 12:51:02 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_539627
2 x OutPort_539892
InPort_539636
InPort_539670
2 x OutPort_539674
InPort_539672
InPort_539697
2 x OutPort_539701
InPort_539699
InPort_539707
2 x OutPort_539711
InPort_539709
InPort_539717
2 x OutPort_539721
InPort_539719
InPort_539727
2 x OutPort_539731
InPort_539729
InPort_539737
2 x OutPort_539741
InPort_539739
InPort_539747
2 x OutPort_539751
InPort_539749

# IfcFlowFitting: Неспецифицируемый_Металлорукав в герметичной PU изоляции_черный (8)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_Металлорукав в герметичной PU изоляции_черный
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_Металлорукав в герметичной PU изоляции_черный:...)
539674
539701
539711
539721
539731
539741
539751
539892

# IfcFlowSegment: Короб с соединительными деталями:КНС_Металлорукав_В герметичной PU изоляции_DN10-50мм_Цвет черный_DKC (16)
In: Этаж 01
Type - PredefinedType: CONDUITSEGMENT
Pset_DistributionFlowElementCommon - Reference: КНС_Металлорукав_В герметичной PU изоляции_DN10-50мм_Цвет черный_DKC
Name (Короб с соединительными деталями:КНС_Металлорукав_В герметичной PU изоляции_DN10-50мм_Цвет черный_DKC:...)
539627
539636
539670
539672
539697
539699
539707
539709
539717
539719
539727
539729
539737
539739
539747
539749
