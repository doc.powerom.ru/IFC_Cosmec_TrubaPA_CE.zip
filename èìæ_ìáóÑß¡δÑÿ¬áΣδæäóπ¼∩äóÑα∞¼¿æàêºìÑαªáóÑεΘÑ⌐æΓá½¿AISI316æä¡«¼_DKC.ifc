Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-10-20T13:46:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 20 13:46:42 2021 * Host: KYAKIMENKO * Database: C:\Users\KYAKIM~1\AppData\Local\Temp\{020E4A6F-1B28-43C2-8606-1AA9C79214E3}\ifc * Database version: 5507 * Database creation date: Wed Oct 20 13:46:41 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 20 13:46:41 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 20 13:46:41 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 1000 х 1000 х 300 мм, КНС_НавесныеШкафыСДвумяДверьмиСЕИзНержавеющейСталиAISI316СДном_DKC:1000 х 1000 х 300 мм:721138
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1000 х 1000 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB10132; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB10132/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение:; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1200 х 1000 х 300 мм, КНС_НавесныеШкафыСДвумяДверьмиСЕИзНержавеющейСталиAISI316СДном_DKC:1200 х 1000 х 300 мм:721140
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1200 х 1000 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB12132; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB12132/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение:; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1200 х 1200 х 300 мм, КНС_НавесныеШкафыСДвумяДверьмиСЕИзНержавеющейСталиAISI316СДном_DKC:1200 х 1200 х 300 мм:721142
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1200 х 1200 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB121232; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB121232/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение:; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 1400 х 1000 х 300 мм, КНС_НавесныеШкафыСДвумяДверьмиСЕИзНержавеющейСталиAISI316СДном_DKC:1400 х 1000 х 300 мм:721144
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 1400 х 1000 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB14132; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB14132/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение:; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 600 х 800 х 300 мм, КНС_НавесныеШкафыСДвумяДверьмиСЕИзНержавеющейСталиAISI316СДном_DKC:600 х 800 х 300 мм:721134
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 600 х 800 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB06832; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB06832/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение:; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 х 1000 х 200 мм, КНС_НавесныеШкафыСДвумяДверьмиСЕИзНержавеющейСталиAISI316СДном_DKC:800 х 1000 х 200 мм:721136
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 800 х 1000 х 200 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB08122; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB08122/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение:; Комментарии к типоразмеру: Металлический корпус

# IfcBuildingElementProxy: 800 х 1000 х 300 мм, КНС_НавесныеШкафыСДвумяДверьмиСЕИзНержавеющейСталиAISI316СДном_DKC:800 х 1000 х 300 мм:721147
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316
Pset_BuildingElementProxyCommon - Reference: 800 х 1000 х 300 мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CEB08132; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/103/R5CEB08132/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000261; Описание: Назначение: • для построения систем автоматизации и распределения электроэнергии. Материал: • каркас и дверь – сталь 1,5 мм, порошковое покрытие RAL 7035; • монтажная плата – оцинкованная сталь 2 мм; • литой уплотнитель – полиуретан. Отличительные особенности: • степень пыле- и влагозащиты – IP55; • степень ударопрочности – IK10; • в двери установлен замок под ключ с двойной бородкой 3 мм; • быстросъемный фланец для ввода кабеля в комплекте с уплотнителем. Комплект поставки: • корпус, монтажная плата, дверь, замок, фланец для ввода кабеля, монтажные аксессуары. Чертежи: • см. на сайте www.dkc.ru в разделе Поддержка; Комментарии к типоразмеру: Металлический корпус
